FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI:append = " file://rpi5-camera.cfg"